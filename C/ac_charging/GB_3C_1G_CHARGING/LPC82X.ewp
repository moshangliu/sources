# IAR project LPC82X.ewp, settings and files
configuration iflash_nxp_lpcxpresso_824 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CORE_M0PLUS
  ICCARM.CCIncludePath2: $PROJ_DIR$; lpc_core\lpc_chip\chip_common; lpc_core\lpc_chip\chip_8xx\config_82x; lpc_core\lpc_chip\chip_8xx; lpc_core\lpc_board\board_common; lpc_core\lpc_board\boards_8xx\nxp_lpcxpresso_824; CMSIS\Include; inc; app; bsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_lpcxpresso_824; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_8xx\config_82x
  OBJCOPY.OOCOutputFile: LPC82X.bin
  ILINK.IlinkOutputFile: periph_gpio.out
  ILINK.IlinkIcfFile: E:\DH_WORK\software\LPC824_tengshi\LPC82X.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    app/: Charging.c crc.c GPRS.c main.c Meter.c remoteupdate.c
    ./: iar_startup_lpc82x.s
    lpc_core/: sysinit.c
  group BSP
    bsp/: adc.c AT45DB081.c Dio.c dma_uart.c Eeprom.c iap.c
  group DRV
    lpc_core/lpc_chip/chip_8xx/: acmp_8xx.c adc_8xx.c chip_8xx.c clock_8xx.c crc_8xx.c dma_8xx.c gpio_8xx.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c iocon_8xx.c pinint_8xx.c pmu_8xx.c sct_8xx.c sct_pwm_8xx.c spi_8xx.c spim_8xx.c spis_8xx.c stopwatch_8xx.c swm_8xx.c syscon_8xx.c sysinit_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c
